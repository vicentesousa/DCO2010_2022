options:
  parameters:
    author: sdr
    generate_options: qt_gui
    id: hands_on_62
    output_language: python
  states: {}

blocks:
- name: mic_gain
  id: variable_qtgui_range
  parameters:
    min_len: '400'
    start: '0'
    step: '0.1'
    stop: '20'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 44.1e3
  states: {}
- name: slider_0
  id: variable_qtgui_range
  parameters:
    min_len: '400'
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: slider_1
  id: variable_qtgui_range
  parameters:
    min_len: '400'
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '44100'
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: '882000'
    tau: '75e-6'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: slider_1
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: slider_0
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: mic_gain
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/sdr/DCO2010_2022-main/original_files/music_files/handson2_file_minicurso_44_1KHz.wav
    repeat: 'True'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: 88.1e6
    gain0: '10'
    samp_rate: '882000'
    sync: none
    type: fc32
  states: {}

connections:
- [analog_wfm_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', analog_wfm_tx_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_add_xx_0, '1']
- [blocks_wavfile_source_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
