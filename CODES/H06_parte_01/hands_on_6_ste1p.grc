options:
  parameters:
    author: sdr
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: hands_on6
  states: {}

blocks:
- name: freq_fina
  id: variable_qtgui_range
  parameters:
    label: Frequencia Fina
    start: '-250e3'
    step: '500'
    stop: 250e3
    value: '0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: Ganho de RF
    start: '0'
    step: '3'
    stop: '50'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: usrp_freq
  id: variable_qtgui_range
  parameters:
    label: Frequencia Central
    start: 88e6
    step: 100e3
    stop: 108e6
    value: 98.9e6
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 115e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 30e3
    win: window.WIN_HANN
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: usrp_freq+freq_fina
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: usrp_freq+freq_fina
    gain0: rf_gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
