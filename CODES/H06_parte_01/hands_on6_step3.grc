options:
  parameters:
    author: sdr
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: hands_on6
  states: {}

blocks:
- name: af_gain
  id: variable_qtgui_range
  parameters:
    label: AF
    start: '0'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: freq_fina
  id: variable_qtgui_range
  parameters:
    label: Frequencia Fina
    start: '-250e3'
    step: '500'
    stop: 250e3
    value: '0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: Ganho de RF
    start: '0'
    step: '3'
    stop: '50'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: usrp_freq
  id: variable_qtgui_range
  parameters:
    label: Frequencia Central
    start: 88e6
    step: 100e3
    stop: 108e6
    value: 98.9e6
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '10'
    deemph_tau: '75e-6'
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    ok_to_block: 'False'
    samp_rate: '44100'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: af_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: af_gain
    type: float
  states: {}
- name: janela
  id: qtgui_tab_widget
  parameters:
    label0: Espectro L
    label1: Espectro R
    num_tabs: '2'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 115e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 30e3
    win: window.WIN_HANN
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: janela@0
    name: '"Espectro L"'
    type: float
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: janela@1
    name: '"Espectro R"'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '441'
    interp: '500'
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '441'
    interp: '500'
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: usrp_freq+freq_fina
    gain0: rf_gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_pll_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_wfm_rcv_pll_0, '0', rational_resampler_xxx_1, '0']
- [analog_wfm_rcv_pll_0, '1', qtgui_freq_sink_x_1, '0']
- [analog_wfm_rcv_pll_0, '1', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '1']
- [low_pass_filter_0, '0', analog_wfm_rcv_pll_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
