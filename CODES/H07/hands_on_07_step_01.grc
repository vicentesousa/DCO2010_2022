options:
  parameters:
    author: teste
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: HO-07-step1
  states: {}

blocks:
- name: fine_tune
  id: variable_qtgui_range
  parameters:
    label: Fine_Frequency
    start: '-250e3'
    step: 1e3
    stop: 250e3
    value: '0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: Ganho de RF
    start: '0'
    step: '3'
    stop: '50'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: usrp_freq
  id: variable_qtgui_range
  parameters:
    label: Frequencia Central
    start: 88e6
    step: 100e3
    stop: 108e6
    value: 98.9e6
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: rf_gain
    freq0: usrp_freq+fine_tune
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: rf_gain
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: usrp_freq+fine_tune
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
