options:
  parameters:
    author: teste
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: HO-07-step2
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    label: Ganho de Audio
    start: '1'
    step: '1'
    stop: '3'
    value: '1'
  states: {}
- name: fine_tune
  id: variable_qtgui_range
  parameters:
    label: Fine_Frequency
    start: '-250e3'
    step: '500'
    stop: 250e3
    value: '0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: Ganho de RF
    start: '0'
    step: '3'
    stop: '50'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: usrp_freq
  id: variable_qtgui_range
  parameters:
    label: Frequencia Central
    start: 88e6
    step: 100e3
    stop: 108e6
    value: 98.9e6
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '1'
    deemph_tau: '75e-6'
    quad_rate: '500000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: rf_gain
    freq0: usrp_freq+fine_tune
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: rf_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,1
    label: Canal L
    showports: 'True'
    type: float
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,1,1,1
    label: Canal R
    showports: 'True'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '500'
    interp: '48'
    type: fff
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '500'
    interp: '48'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_wfm_rcv_pll_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_wfm_rcv_pll_0, '0', rational_resampler_xxx_2, '0']
- [analog_wfm_rcv_pll_0, '1', qtgui_freq_sink_x_2, '0']
- [analog_wfm_rcv_pll_0, '1', rational_resampler_xxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '1']
- [osmosdr_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_pll_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_1, '0']
- [rational_resampler_xxx_2, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
