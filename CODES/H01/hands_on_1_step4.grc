options:
  parameters:
    author: labsdr
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: hands_on_1
  states: {}

blocks:
- name: Tons_musicais
  id: variable_qtgui_chooser
  parameters:
    labels: '[''Pause'',''Do'',''Re'',''Mi'',''Fa'',''Sol'',''La'',''Si'',''Do'']'
    num_opts: '0'
    options: '[0,1,1.125,1.25,1.33,1.5,1.667,1.875,2]'
    orient: Qt.QHBoxLayout
    type: real
    value: '0'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 512*Tons_musicais
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: janela
  id: qtgui_tab_widget
  parameters:
    label0: Epectro
    label1: Waterfall
    num_tabs: '2'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: janela@0
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: janela@1
    type: float
  states: {}

connections:
- [analog_sig_source_x_0_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', audio_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
