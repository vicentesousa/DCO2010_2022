options:
  parameters:
    author: Vinicius
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: Handson_01
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequência Central
    min_len: '50'
    start: 88e6
    step: '100'
    stop: 108e6
    value: 98.9e6
    widget: slider
  states: {}
- name: freq_fina
  id: variable_qtgui_range
  parameters:
    label: Ajuste Fino
    min_len: '50'
    start: '-250e3'
    step: '500'
    stop: 250e3
    value: '0'
    widget: slider
  states: {}
- name: gain_rf
  id: variable_qtgui_range
  parameters:
    label: Ganho (dB)
    min_len: '50'
    start: '0'
    step: '10'
    stop: '110'
    value: '70'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: gain_rf
    freq0: freq+freq_fina
    gain0: gain_rf
    gain_mode0: 'False'
    if_gain0: gain_rf
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 98.9e6
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: Tab 0
    num_tabs: '1'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq+freq_fina
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
