options:
  parameters:
    author: labsdr
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: hands_on_1
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: 'Frequencia Central '
    min_len: '50'
    start: 88e6
    step: '100'
    stop: 108e6
    value: 98.9e6
    widget: slider
  states: {}
- name: freq_fina
  id: variable_qtgui_range
  parameters:
    label: Ajuste Fino
    start: '-250e3'
    step: '500'
    stop: 250e3
    value: '0'
    widget: slider
  states: {}
- name: gain_rf
  id: variable_qtgui_range
  parameters:
    label: Ganho(dB)
    min_len: '50'
    start: '0'
    step: '10'
    stop: '110'
    value: '70'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: freq+freq_fina
    fftsize: '1024'
    type: complex
    ymax: '-60'
    ymin: '-108'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq+freq_fina
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: freq+freq_fina
    gain0: gain_rf
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
