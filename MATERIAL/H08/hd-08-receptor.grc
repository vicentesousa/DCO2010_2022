options:
  parameters:
    author: sdr
    generate_options: qt_gui
    id: receptor
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    label: Fine Frequency
    start: '1'
    step: '1'
    stop: '10'
    value: '10'
  states: {}
- name: filter_taps
  id: variable
  parameters:
    value: firdes.low_pass(1,samp_rate,250000,20000, window.WIN_HAMMING, 6.76)
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: Ganho de RF
    start: '0'
    step: '50'
    stop: '200'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: usrp_freq
  id: variable_qtgui_range
  parameters:
    label: Frequencia Central
    start: 2e9
    step: 1e3
    stop: 3e9
    value: 2.4e9
  states: {}
- name: xlate_tune
  id: variable_qtgui_range
  parameters:
    label: Fine Frequency
    start: '-250e3'
    step: '500'
    stop: 250e3
    value: '0'
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '1'
    deemph_tau: '75e-6'
    quad_rate: '500000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '-xlate_tune'
    decim: '1'
    samp_rate: samp_rate
    taps: filter_taps
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    interp: '12'
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '24'
    interp: '5'
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: usrp_freq
    gain0: rf_gain
    samp_rate: '2380952'
    sync: none
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_pll_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_wfm_rcv_pll_0, '1', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', analog_wfm_rcv_pll_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_1, '0', freq_xlating_fft_filter_ccc_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_1, '0']

metadata:
  file_format: 1
