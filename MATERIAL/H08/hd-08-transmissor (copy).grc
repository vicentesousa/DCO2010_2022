options:
  parameters:
    author: sdr
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: handson8
  states: {}

blocks:
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: ganho
    start: '0'
    step: '1'
    stop: '10'
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: 48000*4
    tau: '75e-6'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/sdr/DCO2010_2022-antigo/original_files/music_files/handson2_file_minicurso_48KHz.wav
    repeat: 'True'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    interp: '25'
    type: ccc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 2.4e9
    clock_source0: internal
    gain0: rf_gain
    samp_rate: '2380952'
    sync: none
    type: fc32
  states: {}

connections:
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
