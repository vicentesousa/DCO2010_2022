<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>title</key><value>Ho1_USRP</value></param>
<param><key>author</key><value>Leonardo</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_rf</value></param>
<param><key>label</key><value>Ganho (dB)</value></param>
<param><key>value</key><value>70</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>110</value></param>
<param><key>step</key><value>10</value></param>
<param><key>widget</key><value>slider</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>50</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq+freq_fina</value></param>
<param><key>gain0</key><value>gain_rf</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>janela</value></param>
<param><key>num_tabs</key><value>2</value></param>
<param><key>label0</key><value>Waterfall</value></param>
<param><key>label1</key><value>Espectro WBFM</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>freq+freq_fina</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>int_min</key><value>-100</value></param>
<param><key>gui_hint</key><value>janela@0</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_fina</value></param>
<param><key>label</key><value>Ajuste Fino</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>-250e3</value></param>
<param><key>stop</key><value>250e3</value></param>
<param><key>step</key><value>500</value></param>
<param><key>widget</key><value>slider</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>50</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequencia Central</value></param>
<param><key>value</key><value>98.9e6</value></param>
<param><key>start</key><value>88e6</value></param>
<param><key>stop</key><value>108e6</value></param>
<param><key>step</key><value>100</value></param>
<param><key>widget</key><value>slider</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>50</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>98.9e6</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>janela@1</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
