<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>hands_on_06</value></param>
<param><key>title</key><value>Transmissao FM simples</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>slider_1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>slider_0</value></param>
<param><key>value</key><value>1</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>10</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>400</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>slider_1</value></param>
<param><key>value</key><value>1</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>10</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>400</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>slider_0</value></param>
</block>
<block>
<key>analog_wfm_tx</key>
<param><key>id</key><value>analog_wfm_tx_0</value></param>
<param><key>audio_rate</key><value>44100</value></param>
<param><key>quad_rate</key><value>882000</value></param>
<param><key>tau</key><value>75e-6</value></param>
<param><key>max_dev</key><value>75e3</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>882000</value></param>
<param><key>center_freq0</key><value>100500000</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>ant0</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/home/gppcom/Dropbox/digital_transmission/short_courses/introduction_to_GNU_and_USRP/New_hands_on/handson2_file_minicurso_44_1KHz.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_wfm_tx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>analog_wfm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
